Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-04-20T16:32:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 20 16:32:34 2018 * Host: B3ROBRAWR3853 * Database: C:\Users\LC\AppData\Local\Temp\{1C313DA9-6921-4AA1-B7A0-A42D72D4742A}\ifc * Database version: 5507 * Database creation date: Fri Apr 20 16:32:34 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Apr 20 16:32:34 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 20 16:32:34 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcElectricAppliance: FAD-A1.1, E_Time Switcher_MEPcontent_ABB_FAD-A1 1_INT-EN:FAD-A1.1:1363545
In: V00
Type - Material: Color RGB 170-170-170, Color RGB 127-127-127, Color RGB 245-245-245
Type - Dimensions - Depth: 57 mm; Height: 93 mm; Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Width: 72 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC
Type - Electrical Engineering - Connection Voltage: 18 V
Type - Identity Data - Article Description: FAD/A1.1 DCF Antenna for Radio Time Switch; Article Type: FAD/A1.1; Category: EL_BUSSYSTEM_WITH_ADDRESS; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: FAD/A1.1 DCF Antenna for Radio Time Switch; EMCS Version: 3.0; ETIM Article Class: EC002296; Family Version: 11.14; GTIN: 4016779906685; Manufacturer: ABB; Manufacturer Art. No.: 2CDG120040R0011; Manufacturer URL: https://new.abb.com/products/2CDG120040R0011; MEPcontent Class: COMMUNICATION_DEVICE_INTERCOM; Model: FAD/A1.1; OmniClass Number: 23.85.50.14.21; OmniClass Title: Intercommunication Equipment; Product Line: KNX - Automation, Logic and Time Control - Time Switches; Revit Version: 2016; Type Name: FAD-A1.1; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Communication Devices; Family Name: E_Time Switcher_MEPcontent_ABB_FAD-A1 1_INT-EN
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Offset: 0 mm
Dimensions - Area: 0.0225918 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.000235522 m3
Electrical - Loads - Power: 0 W
Identity Data - Function Code: E6222BS; Mark: 1
Other - Family: E_Time Switcher_MEPcontent_ABB_FAD-A1 1_INT-EN: FAD-A1.1; Family and Type: E_Time Switcher_MEPcontent_ABB_FAD-A1 1_INT-EN: FAD-A1.1; Type: E_Time Switcher_MEPcontent_ABB_FAD-A1 1_INT-EN: FAD-A1.1; Type Id: E_Time Switcher_MEPcontent_ABB_FAD-A1 1_INT-EN: FAD-A1.1
Phasing - Phase Created: 4. Plan over 10 jaar
